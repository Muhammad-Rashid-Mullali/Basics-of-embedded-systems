# Keil uVision project dc motor interface.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: dc motor interface +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: dc_motor.c
